# Keil uVision project osu.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: osu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;.\SYSTEM\STM32_USB-FS-Device_Driver\inc;.\SYSTEM\sys;.\FWLIB;.\SYSTEM\delay;.\SYSTEM\osu
  memory RVCT4: ROM 0x8010000 size 0xffff
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USB-FS
    ./SYSTEM/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Core
    ./SYSTEM/sys/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group Main
    ./src/: hw_config.c main.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group FWLIB
    ./FWLIB/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/osu/: osu.c
